# Keil uVision project RtkLib.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RtkLib +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_HAL_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group USER
    ./: main.c ephemeris.c interrupt.c lambda.c Myhal_uart.c pntpos.c rcvraw.c rtkcmn.c rtkpos.c rtksvr.c solution.c stm32f4xx_hal_msp.c ublox.c SuperStarII.c
  group FWLIB
    ../FWLIB/src/: stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
